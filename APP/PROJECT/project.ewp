# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\BSP\inc; ..\IAP\inc; ..\LIB\inc; ..\USER\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Linker\lnkstm8l151c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/src/: Pulse_Acquire.c rtc.c Temperature.c TPB21.c uart.c
    ../BSP/inc/: Pulse_Acquire.h rtc.h Temperature.h TPB21.h uart.h
  group IAP
    ../IAP/src/: IAP.c
    ../IAP/inc/: IAP.h
  group LIB
    ../LIB/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_usart.c stm8l15x_wwdg.c
  group LINKER
    ../Linker/: lnkstm8l151c8.icf
  group USER
    ../USER/src/: Globaldata.c main.c mcu_init.c Save.c stm8l15x_it.c Sys_Timer.c
    ../USER/inc/: Globaldata.h include.h main.h mcu_init.h save.h Sys_timer.h
